Commit message: unkown

File: ocs2_robotic_assets/resources/mobile_manipulator/raigor/urdf/raigor.urdf (robot description, URDF)
Before this commit: robot raigor, 18 links, 17 joints
Joints:
- joint associate_joint: origin xyz=0.365 0 0.28 rpy=0 0 0 -> xyz=0.365 0 0.28 rpy=0 0 -1.57
